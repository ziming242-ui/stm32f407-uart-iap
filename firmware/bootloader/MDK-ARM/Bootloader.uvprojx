# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0801FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;..\..\..\common\include;..\..\..\vendor\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\vendor\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\vendor\STM32CubeF4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\vendor\STM32CubeF4\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../../vendor/STM32CubeF4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../../vendor/STM32CubeF4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Common
    ../../../common/src/: iap_crc.c iap_protocol.c
  group Bootloader/Core
    ../Core/Src/: main.c board.c stm32f4xx_it.c flash_if.c metadata.c boot_service.c boot_flow.c app_jump.c
  group STM32F4xx HAL
    ../../../vendor/STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c
